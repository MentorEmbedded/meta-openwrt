FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://single_runlevel.patch"
