require libuv.inc

SRC_URI[md5sum] = "894bf14cbef538805af923fa9df52f2a"
SRC_URI[sha256sum] = "11d10f12d68fa655fff18c6021e8e45bc610e7baee006f17247b1830ee316093"
